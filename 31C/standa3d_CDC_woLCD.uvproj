# Keil uVision project standa3d_CDC_woLCD.uvproj, settings and files
target standa3d_woLCD (MCS-51)
  device: AT89C5131 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: standa3d_woLCD +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: KEIL
  group system
    ./: standa3d.c
